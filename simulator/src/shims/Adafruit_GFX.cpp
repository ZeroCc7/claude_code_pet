#include "Adafruit_GFX.h"
#include <cmath>
#include <climits>

const uint8_t Adafruit_GFX::font[] = {
    // Characters 0x00-0x1F (control characters, all blank)
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x00 NUL
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x01 SOH
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x02 STX
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x03 ETX
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x04 EOT
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x05 ENQ
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x06 ACK
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x07 BEL
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x08 BS
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x09 HT
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x0A LF
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x0B VT
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x0C FF
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x0D CR
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x0E SO
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x0F SI
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x10 DLE
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x11 DC1
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x12 DC2
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x13 DC3
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x14 DC4
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x15 NAK
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x16 SYN
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x17 ETB
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x18 CAN
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x19 EM
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x1A SUB
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x1B ESC
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x1C FS
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x1D GS
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x1E RS
    0x00, 0x00, 0x00, 0x00, 0x00, // 0x1F US
    0x00, 0x00, 0x00, 0x00, 0x00, //   (0x20) space
    0x00, 0x00, 0x5F, 0x00, 0x00, // ! (0x21)
    0x00, 0x07, 0x00, 0x07, 0x00, // " (0x22)
    0x14, 0x7F, 0x14, 0x7F, 0x14, // # (0x23)
    0x24, 0x2A, 0x7F, 0x2A, 0x12, // $ (0x24)
    0x23, 0x13, 0x08, 0x64, 0x62, // % (0x25)
    0x36, 0x49, 0x56, 0x20, 0x50, // & (0x26)
    0x00, 0x08, 0x07, 0x03, 0x00, // ' (0x27)
    0x00, 0x1C, 0x22, 0x41, 0x00, // ( (0x28)
    0x00, 0x41, 0x22, 0x1C, 0x00, // ) (0x29)
    0x2A, 0x1C, 0x7F, 0x1C, 0x2A, // * (0x2A)
    0x08, 0x08, 0x3E, 0x08, 0x08, // + (0x2B)
    0x00, 0x80, 0x70, 0x30, 0x00, // , (0x2C)
    0x08, 0x08, 0x08, 0x08, 0x08, // - (0x2D)
    0x00, 0x00, 0x60, 0x60, 0x00, // . (0x2E)
    0x20, 0x10, 0x08, 0x04, 0x02, // / (0x2F)
    0x3E, 0x51, 0x49, 0x45, 0x3E, // 0 (0x30)
    0x00, 0x42, 0x7F, 0x40, 0x00, // 1 (0x31)
    0x72, 0x49, 0x49, 0x49, 0x46, // 2 (0x32)
    0x21, 0x41, 0x49, 0x4D, 0x33, // 3 (0x33)
    0x18, 0x14, 0x12, 0x7F, 0x10, // 4 (0x34)
    0x27, 0x45, 0x45, 0x45, 0x39, // 5 (0x35)
    0x3C, 0x4A, 0x49, 0x49, 0x31, // 6 (0x36)
    0x41, 0x21, 0x11, 0x09, 0x07, // 7 (0x37)
    0x36, 0x49, 0x49, 0x49, 0x36, // 8 (0x38)
    0x46, 0x49, 0x49, 0x29, 0x1E, // 9 (0x39)
    0x00, 0x00, 0x14, 0x00, 0x00, // : (0x3A)
    0x00, 0x40, 0x34, 0x00, 0x00, // ; (0x3B)
    0x00, 0x08, 0x14, 0x22, 0x41, // < (0x3C)
    0x14, 0x14, 0x14, 0x14, 0x14, // = (0x3D)
    0x00, 0x41, 0x22, 0x14, 0x08, // > (0x3E)
    0x02, 0x01, 0x59, 0x09, 0x06, // ? (0x3F)
    0x3E, 0x41, 0x5D, 0x59, 0x4E, // @ (0x40)
    0x7C, 0x12, 0x11, 0x12, 0x7C, // A (0x41)
    0x7F, 0x49, 0x49, 0x49, 0x36, // B (0x42)
    0x3E, 0x41, 0x41, 0x41, 0x22, // C (0x43)
    0x7F, 0x41, 0x41, 0x41, 0x3E, // D (0x44)
    0x7F, 0x49, 0x49, 0x49, 0x41, // E (0x45)
    0x7F, 0x09, 0x09, 0x09, 0x01, // F (0x46)
    0x3E, 0x41, 0x41, 0x51, 0x73, // G (0x47)
    0x7F, 0x08, 0x08, 0x08, 0x7F, // H (0x48)
    0x00, 0x41, 0x7F, 0x41, 0x00, // I (0x49)
    0x20, 0x40, 0x41, 0x3F, 0x01, // J (0x4A)
    0x7F, 0x08, 0x14, 0x22, 0x41, // K (0x4B)
    0x7F, 0x40, 0x40, 0x40, 0x40, // L (0x4C)
    0x7F, 0x02, 0x1C, 0x02, 0x7F, // M (0x4D)
    0x7F, 0x04, 0x08, 0x10, 0x7F, // N (0x4E)
    0x3E, 0x41, 0x41, 0x41, 0x3E, // O (0x4F)
    0x7F, 0x09, 0x09, 0x09, 0x06, // P (0x50)
    0x3E, 0x41, 0x51, 0x21, 0x5E, // Q (0x51)
    0x7F, 0x09, 0x19, 0x29, 0x46, // R (0x52)
    0x26, 0x49, 0x49, 0x49, 0x32, // S (0x53)
    0x03, 0x01, 0x7F, 0x01, 0x03, // T (0x54)
    0x3F, 0x40, 0x40, 0x40, 0x3F, // U (0x55)
    0x1F, 0x20, 0x40, 0x20, 0x1F, // V (0x56)
    0x3F, 0x40, 0x38, 0x40, 0x3F, // W (0x57)
    0x63, 0x14, 0x08, 0x14, 0x63, // X (0x58)
    0x03, 0x04, 0x78, 0x04, 0x03, // Y (0x59)
    0x61, 0x59, 0x49, 0x4D, 0x43, // Z (0x5A)
    0x00, 0x7F, 0x41, 0x41, 0x41, // [ (0x5B)
    0x02, 0x04, 0x08, 0x10, 0x20, // \ (0x5C) backslash
    0x00, 0x41, 0x41, 0x41, 0x7F, // ] (0x5D)
    0x04, 0x02, 0x01, 0x02, 0x04, // ^ (0x5E)
    0x40, 0x40, 0x40, 0x40, 0x40, // _ (0x5F)
    0x00, 0x03, 0x07, 0x08, 0x00, // ` (0x60)
    0x20, 0x54, 0x54, 0x78, 0x40, // a (0x61)
    0x7F, 0x28, 0x44, 0x44, 0x38, // b (0x62)
    0x38, 0x44, 0x44, 0x44, 0x28, // c (0x63)
    0x38, 0x44, 0x44, 0x28, 0x7F, // d (0x64)
    0x38, 0x54, 0x54, 0x54, 0x18, // e (0x65)
    0x00, 0x08, 0x7E, 0x09, 0x02, // f (0x66)
    0x18, 0xA4, 0xA4, 0x9C, 0x78, // g (0x67)
    0x7F, 0x08, 0x04, 0x04, 0x78, // h (0x68)
    0x00, 0x44, 0x7D, 0x40, 0x00, // i (0x69)
    0x20, 0x40, 0x40, 0x3D, 0x00, // j (0x6A)
    0x7F, 0x10, 0x28, 0x44, 0x00, // k (0x6B)
    0x00, 0x41, 0x7F, 0x40, 0x00, // l (0x6C)
    0x7C, 0x04, 0x78, 0x04, 0x78, // m (0x6D)
    0x7C, 0x08, 0x04, 0x04, 0x78, // n (0x6E)
    0x38, 0x44, 0x44, 0x44, 0x38, // o (0x6F)
    0xFC, 0x18, 0x24, 0x24, 0x18, // p (0x70)
    0x18, 0x24, 0x24, 0x18, 0xFC, // q (0x71)
    0x7C, 0x08, 0x04, 0x04, 0x08, // r (0x72)
    0x48, 0x54, 0x54, 0x54, 0x24, // s (0x73)
    0x04, 0x04, 0x3F, 0x44, 0x24, // t (0x74)
    0x3C, 0x40, 0x40, 0x20, 0x7C, // u (0x75)
    0x1C, 0x20, 0x40, 0x20, 0x1C, // v (0x76)
    0x3C, 0x40, 0x30, 0x40, 0x3C, // w (0x77)
    0x44, 0x28, 0x10, 0x28, 0x44, // x (0x78)
    0x4C, 0x90, 0x90, 0x90, 0x7C, // y (0x79)
    0x44, 0x64, 0x54, 0x4C, 0x44, // z (0x7A)
    0x00, 0x08, 0x36, 0x41, 0x00, // { (0x7B)
    0x00, 0x00, 0x77, 0x00, 0x00, // | (0x7C)
    0x00, 0x41, 0x36, 0x08, 0x00, // } (0x7D)
    0x02, 0x01, 0x02, 0x04, 0x02, // ~ (0x7E)
    0x3C, 0x26, 0x23, 0x26, 0x3C, // DEL (0x7F)
    0x1E, 0xA1, 0xA1, 0x61, 0x12, // Ç (0x80)
    0x3A, 0x40, 0x40, 0x20, 0x7A, // ü (0x81)
    0x38, 0x54, 0x54, 0x55, 0x59, // é (0x82)
    0x3C, 0x4A, 0x48, 0x49, 0x30, // â (0x83)
    0x3C, 0x56, 0x54, 0x44, 0x78, // ä (0x84)
    0x7C, 0x0A, 0x09, 0x7F, 0x49, // à (0x85)
    0x32, 0x49, 0x79, 0x41, 0x3E, // å (0x86)
    0x7E, 0x11, 0x11, 0x11, 0x7E, // ç (0x87)
    0x7F, 0x11, 0x11, 0x11, 0x7E, // ê (0x88)
    0x3C, 0x42, 0x41, 0x42, 0x3C, // ë (0x89)
    0x7C, 0x12, 0x11, 0x12, 0x7C, // è (0x8A)
    0x00, 0x00, 0x00, 0x00, 0x00, // ï (0x8B) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // î (0x8C) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ì (0x8D) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Ä (0x8E) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Å (0x8F) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // É (0x90) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // æ (0x91) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Æ (0x92) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ô (0x93) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ö (0x94) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ò (0x95) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // û (0x96) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ù (0x97) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ÿ (0x98) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Ö (0x99) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Ü (0x9A) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ¢ (0x9B) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // £ (0x9C) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ¥ (0x9D) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ₧ (0x9E) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ƒ (0x9F) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // á (0xA0) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // í (0xA1) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ó (0xA2) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ú (0xA3) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ñ (0xA4) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Ñ (0xA5) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ª (0xA6) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // º (0xA7) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ¿ (0xA8) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ⌐ (0xA9) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ¬ (0xAA) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ½ (0xAB) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ¼ (0xAC) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ¡ (0xAD) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // « (0xAE) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // » (0xAF) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ░ (0xB0) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ▒ (0xB1) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ▓ (0xB2) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // │ (0xB3) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ┤ (0xB4) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╡ (0xB5) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╢ (0xB6) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╖ (0xB7) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╕ (0xB8) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╣ (0xB9) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ║ (0xBA) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╗ (0xBB) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╝ (0xBC) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╜ (0xBD) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╛ (0xBE) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ┐ (0xBF) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // └ (0xC0) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ┴ (0xC1) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ┬ (0xC2) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ├ (0xC3) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ─ (0xC4) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ┼ (0xC5) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╞ (0xC6) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╟ (0xC7) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╚ (0xC8) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╔ (0xC9) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╩ (0xCA) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╦ (0xCB) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╠ (0xCC) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ═ (0xCD) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╬ (0xCE) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╧ (0xCF) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╨ (0xD0) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╤ (0xD1) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╥ (0xD2) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╙ (0xD3) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╘ (0xD4) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╒ (0xD5) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╓ (0xD6) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╫ (0xD7) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ╪ (0xD8) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ┘ (0xD9) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ┌ (0xDA) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // █ (0xDB) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ▄ (0xDC) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ▌ (0xDD) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ▐ (0xDE) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ▀ (0xDF) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // α (0xE0) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ß (0xE1) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Γ (0xE2) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // π (0xE3) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Σ (0xE4) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // σ (0xE5) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // µ (0xE6) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // τ (0xE7) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Φ (0xE8) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Θ (0xE9) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // Ω (0xEA) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // δ (0xEB) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ∞ (0xEC) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // φ (0xED) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ε (0xEE) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ∩ (0xEF) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ≡ (0xF0) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ± (0xF1) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ≥ (0xF2) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ≤ (0xF3) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ⌠ (0xF4) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ⌡ (0xF5) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ÷ (0xF6) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ≈ (0xF7) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ° (0xF8) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ∙ (0xF9) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // · (0xFA) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // √ (0xFB) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ⁿ (0xFC) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ² (0xFD) (unused)
    0x00, 0x00, 0x00, 0x00, 0x00, // ■ (0xFE) (unused)
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, //   (0xFF) solid block
};

Adafruit_GFX::Adafruit_GFX(int16_t w, int16_t h)
    : WIDTH_(w), HEIGHT_(h), width_(w), height_(h) {
    framebuffer_ = new uint16_t[w * h]{};
    owns_buffer_ = true;
}

Adafruit_GFX::~Adafruit_GFX() {
    if (owns_buffer_ && framebuffer_) {
        delete[] framebuffer_;
        framebuffer_ = nullptr;
    }
}

void Adafruit_GFX::drawPixel(int16_t x, int16_t y, uint16_t color) {
    if (x < 0 || x >= width_ || y < 0 || y >= height_) return;
    framebuffer_[y * width_ + x] = color;
}

void Adafruit_GFX::drawLine(int16_t x0, int16_t y0, int16_t x1, int16_t y1, uint16_t color) {
    if (x0 == x1) {
        if (y0 > y1) std::swap(y0, y1);
        drawFastVLine(x0, y0, y1 - y0 + 1, color);
        return;
    }
    if (y0 == y1) {
        if (x0 > x1) std::swap(x0, x1);
        drawFastHLine(x0, y0, x1 - x0 + 1, color);
        return;
    }

    bool steep = std::abs(y1 - y0) > std::abs(x1 - x0);
    if (steep) {
        std::swap(x0, y0);
        std::swap(x1, y1);
    }
    if (x0 > x1) {
        std::swap(x0, x1);
        std::swap(y0, y1);
    }

    int16_t dx = x1 - x0;
    int16_t dy = std::abs(y1 - y0);
    int16_t err = dx / 2;
    int16_t ystep = (y0 < y1) ? 1 : -1;

    for (; x0 <= x1; x0++) {
        if (steep)
            drawPixel(y0, x0, color);
        else
            drawPixel(x0, y0, color);
        err -= dy;
        if (err < 0) {
            y0 += ystep;
            err += dx;
        }
    }
}

void Adafruit_GFX::drawRect(int16_t x, int16_t y, int16_t w, int16_t h, uint16_t color) {
    drawFastHLine(x, y, w, color);
    drawFastHLine(x, y + h - 1, w, color);
    drawFastVLine(x, y, h, color);
    drawFastVLine(x + w - 1, y, h, color);
}

void Adafruit_GFX::fillRect(int16_t x, int16_t y, int16_t w, int16_t h, uint16_t color) {
    int16_t x0 = std::max((int16_t)0, x);
    int16_t y0 = std::max((int16_t)0, y);
    int16_t x1 = std::min((int16_t)(width_ - 1), (int16_t)(x + w - 1));
    int16_t y1 = std::min((int16_t)(height_ - 1), (int16_t)(y + h - 1));
    for (int16_t row = y0; row <= y1; row++) {
        for (int16_t col = x0; col <= x1; col++) {
            framebuffer_[row * width_ + col] = color;
        }
    }
}

void Adafruit_GFX::fillScreen(uint16_t color) {
    std::fill(framebuffer_, framebuffer_ + (width_ * height_), color);
}

void Adafruit_GFX::drawFastVLine(int16_t x, int16_t y, int16_t h, uint16_t color) {
    if (x < 0 || x >= width_) return;
    int16_t y0 = std::max((int16_t)0, y);
    int16_t y1 = std::min((int16_t)(height_ - 1), (int16_t)(y + h - 1));
    for (int16_t row = y0; row <= y1; row++) {
        framebuffer_[row * width_ + x] = color;
    }
}

void Adafruit_GFX::drawFastHLine(int16_t x, int16_t y, int16_t w, uint16_t color) {
    if (y < 0 || y >= height_) return;
    int16_t x0 = std::max((int16_t)0, x);
    int16_t x1 = std::min((int16_t)(width_ - 1), (int16_t)(x + w - 1));
    for (int16_t col = x0; col <= x1; col++) {
        framebuffer_[y * width_ + col] = color;
    }
}

void Adafruit_GFX::drawCircle(int16_t x0, int16_t y0, int16_t r, uint16_t color) {
    int16_t f = 1 - r;
    int16_t ddF_x = 1;
    int16_t ddF_y = -2 * r;
    int16_t x = 0;
    int16_t y = r;

    drawPixel(x0, y0 + r, color);
    drawPixel(x0, y0 - r, color);
    drawPixel(x0 + r, y0, color);
    drawPixel(x0 - r, y0, color);

    while (x < y) {
        if (f >= 0) {
            y--;
            ddF_y += 2;
            f += ddF_y;
        }
        x++;
        ddF_x += 2;
        f += ddF_x;

        drawPixel(x0 + x, y0 + y, color);
        drawPixel(x0 - x, y0 + y, color);
        drawPixel(x0 + x, y0 - y, color);
        drawPixel(x0 - x, y0 - y, color);
        drawPixel(x0 + y, y0 + x, color);
        drawPixel(x0 - y, y0 + x, color);
        drawPixel(x0 + y, y0 - x, color);
        drawPixel(x0 - y, y0 - x, color);
    }
}

void Adafruit_GFX::drawCircleHelper(int16_t x0, int16_t y0, int16_t r, uint8_t cornermask, uint16_t color) {
    int16_t f = 1 - r;
    int16_t ddF_x = 1;
    int16_t ddF_y = -2 * r;
    int16_t x = 0;
    int16_t y = r;

    while (x < y) {
        if (f >= 0) {
            y--;
            ddF_y += 2;
            f += ddF_y;
        }
        x++;
        ddF_x += 2;
        f += ddF_x;
        if (cornermask & 0x4) {
            drawPixel(x0 + x, y0 + y, color);
            drawPixel(x0 + y, y0 + x, color);
        }
        if (cornermask & 0x2) {
            drawPixel(x0 + x, y0 - y, color);
            drawPixel(x0 + y, y0 - x, color);
        }
        if (cornermask & 0x8) {
            drawPixel(x0 - y, y0 + x, color);
            drawPixel(x0 - x, y0 + y, color);
        }
        if (cornermask & 0x1) {
            drawPixel(x0 - y, y0 - x, color);
            drawPixel(x0 - x, y0 - y, color);
        }
    }
}

void Adafruit_GFX::fillCircle(int16_t x0, int16_t y0, int16_t r, uint16_t color) {
    drawFastVLine(x0, y0 - r, 2 * r + 1, color);
    fillCircleHelper(x0, y0, r, 3, 0, color);
}

void Adafruit_GFX::fillCircleHelper(int16_t x0, int16_t y0, int16_t r, uint8_t corners, int16_t delta, uint16_t color) {
    int16_t f = 1 - r;
    int16_t ddF_x = 1;
    int16_t ddF_y = -2 * r;
    int16_t x = 0;
    int16_t y = r;
    int16_t px = x;
    int16_t py = y;

    delta++;

    while (x < y) {
        if (f >= 0) {
            y--;
            ddF_y += 2;
            f += ddF_y;
        }
        x++;
        ddF_x += 2;
        f += ddF_x;
        if (x < (y + 1)) {
            if (corners & 1) drawFastVLine(x0 + x, y0 - y, 2 * y + delta, color);
            if (corners & 2) drawFastVLine(x0 - x, y0 - y, 2 * y + delta, color);
        }
        if (y != py) {
            if (corners & 1) drawFastVLine(x0 + py, y0 - px, 2 * px + delta, color);
            if (corners & 2) drawFastVLine(x0 - py, y0 - px, 2 * px + delta, color);
            py = y;
        }
        px = x;
    }
}

void Adafruit_GFX::drawTriangle(int16_t x0, int16_t y0, int16_t x1, int16_t y1, int16_t x2, int16_t y2, uint16_t color) {
    drawLine(x0, y0, x1, y1, color);
    drawLine(x1, y1, x2, y2, color);
    drawLine(x2, y2, x0, y0, color);
}

void Adafruit_GFX::fillTriangle(int16_t x0, int16_t y0, int16_t x1, int16_t y1, int16_t x2, int16_t y2, uint16_t color) {
    int16_t a, b, y, last;

    if (y0 > y1) { std::swap(y0, y1); std::swap(x0, x1); }
    if (y1 > y2) { std::swap(y2, y1); std::swap(x2, x1); }
    if (y0 > y1) { std::swap(y0, y1); std::swap(x0, x1); }

    if (y0 == y2) {
        a = b = x0;
        if (x1 < a) a = x1;
        else if (x1 > b) b = x1;
        if (x2 < a) a = x2;
        else if (x2 > b) b = x2;
        drawFastHLine(a, y0, b - a + 1, color);
        return;
    }

    int16_t dx01 = x1 - x0, dy01 = y1 - y0;
    int16_t dx02 = x2 - x0, dy02 = y2 - y0;
    int16_t dx12 = x2 - x1, dy12 = y2 - y1;
    int32_t sa = 0, sb = 0;

    if (y1 == y2) last = y1;
    else last = y1 - 1;

    for (y = y0; y <= last; y++) {
        a = x0 + sa / dy01;
        b = x0 + sb / dy02;
        sa += dx01;
        sb += dx02;
        if (a > b) std::swap(a, b);
        drawFastHLine(a, y, b - a + 1, color);
    }

    sa = (int32_t)dx12 * (y - y1);
    sb = (int32_t)dx02 * (y - y0);
    for (; y <= y2; y++) {
        a = x1 + sa / dy12;
        b = x0 + sb / dy02;
        sa += dx12;
        sb += dx02;
        if (a > b) std::swap(a, b);
        drawFastHLine(a, y, b - a + 1, color);
    }
}

void Adafruit_GFX::drawRoundRect(int16_t x, int16_t y, int16_t w, int16_t h, int16_t r, uint16_t color) {
    int16_t max_radius = ((w < h) ? w : h) / 2;
    if (r > max_radius) r = max_radius;

    drawFastHLine(x + r, y, w - 2 * r, color);
    drawFastHLine(x + r, y + h - 1, w - 2 * r, color);
    drawFastVLine(x, y + r, h - 2 * r, color);
    drawFastVLine(x + w - 1, y + r, h - 2 * r, color);

    drawCircleHelper(x + r, y + r, r, 1, color);
    drawCircleHelper(x + w - r - 1, y + r, r, 2, color);
    drawCircleHelper(x + w - r - 1, y + h - r - 1, r, 4, color);
    drawCircleHelper(x + r, y + h - r - 1, r, 8, color);
}

void Adafruit_GFX::fillRoundRect(int16_t x, int16_t y, int16_t w, int16_t h, int16_t r, uint16_t color) {
    int16_t max_radius = ((w < h) ? w : h) / 2;
    if (r > max_radius) r = max_radius;

    fillRect(x + r, y, w - 2 * r, h, color);

    fillCircleHelper(x + w - r - 1, y + r, r, 1, h - 2 * r - 1, color);
    fillCircleHelper(x + r, y + r, r, 2, h - 2 * r - 1, color);
}

void Adafruit_GFX::drawBitmap(int16_t x, int16_t y, const uint8_t bitmap[], int16_t w, int16_t h, uint16_t color) {
    int16_t byteWidth = (w + 7) / 8;
    uint8_t byte_val = 0;
    for (int16_t j = 0; j < h; j++, y++) {
        for (int16_t i = 0; i < w; i++) {
            if (i & 7) byte_val <<= 1;
            else byte_val = bitmap[j * byteWidth + i / 8];
            if (byte_val & 0x80) drawPixel(x + i, y, color);
        }
    }
}

void Adafruit_GFX::drawBitmap(int16_t x, int16_t y, const uint8_t bitmap[], int16_t w, int16_t h, uint16_t color, uint16_t bg) {
    int16_t byteWidth = (w + 7) / 8;
    uint8_t byte_val = 0;
    for (int16_t j = 0; j < h; j++, y++) {
        for (int16_t i = 0; i < w; i++) {
            if (i & 7) byte_val <<= 1;
            else byte_val = bitmap[j * byteWidth + i / 8];
            drawPixel(x + i, y, (byte_val & 0x80) ? color : bg);
        }
    }
}

void Adafruit_GFX::drawXBitmap(int16_t x, int16_t y, const uint8_t bitmap[], int16_t w, int16_t h, uint16_t color) {
    int16_t byteWidth = (w + 7) / 8;
    uint8_t byte_val = 0;
    for (int16_t j = 0; j < h; j++, y++) {
        for (int16_t i = 0; i < w; i++) {
            if (i & 7) byte_val >>= 1;
            else byte_val = bitmap[j * byteWidth + i / 8];
            if (byte_val & 0x01) drawPixel(x + i, y, color);
        }
    }
}

void Adafruit_GFX::drawRGBBitmap(int16_t x, int16_t y, const uint16_t *bitmap, int16_t w, int16_t h) {
    int16_t x0 = std::max((int16_t)0, x);
    int16_t y0 = std::max((int16_t)0, y);
    int16_t x1 = std::min((int16_t)(width_ - 1), (int16_t)(x + w - 1));
    int16_t y1 = std::min((int16_t)(height_ - 1), (int16_t)(y + h - 1));

    for (int16_t row = y0; row <= y1; row++) {
        for (int16_t col = x0; col <= x1; col++) {
            int16_t src_x = col - x;
            int16_t src_y = row - y;
            framebuffer_[row * width_ + col] = bitmap[src_y * w + src_x];
        }
    }
}

void Adafruit_GFX::drawRGBBitmap(int16_t x, int16_t y, const uint16_t *bitmap, const uint8_t *mask, int16_t w, int16_t h) {
    int16_t x0 = std::max((int16_t)0, x);
    int16_t y0 = std::max((int16_t)0, y);
    int16_t x1 = std::min((int16_t)(width_ - 1), (int16_t)(x + w - 1));
    int16_t y1 = std::min((int16_t)(height_ - 1), (int16_t)(y + h - 1));

    // Mask is row-aligned: each row uses ceil(w/8) bytes, MSB-first
    const int16_t byteWidth = (w + 7) / 8;

    for (int16_t row = y0; row <= y1; row++) {
        for (int16_t col = x0; col <= x1; col++) {
            int16_t src_x = col - x;
            int16_t src_y = row - y;
            uint8_t mask_byte = mask[src_y * byteWidth + src_x / 8];
            if (mask_byte & (0x80 >> (src_x % 8))) {
                framebuffer_[row * width_ + col] = bitmap[src_y * w + src_x];
            }
        }
    }
}

void Adafruit_GFX::drawChar(int16_t x, int16_t y, unsigned char c, uint16_t color, uint16_t bg, uint8_t size_x, uint8_t size_y) {
    uint8_t char_idx = c;
    if (!_cp437 && char_idx >= 176) char_idx++;

    if (char_idx > 255) char_idx = 255;

    uint16_t font_offset = char_idx * 5;

    if ((x >= width_) || (y >= height_) ||
        ((x + 6 * size_x - 1) < 0) || ((y + 8 * size_y - 1) < 0))
        return;

    bool bg_same = (color == bg);

    for (int8_t i = 0; i < 5; i++) {
        uint8_t line = font[font_offset + i];
        for (int8_t j = 0; j < 8; j++, line >>= 1) {
            if (line & 1) {
                if (size_x == 1 && size_y == 1)
                    drawPixel(x + i, y + j, color);
                else
                    fillRect(x + i * size_x, y + j * size_y, size_x, size_y, color);
            } else if (!bg_same) {
                if (size_x == 1 && size_y == 1)
                    drawPixel(x + i, y + j, bg);
                else
                    fillRect(x + i * size_x, y + j * size_y, size_x, size_y, bg);
            }
        }
    }
    if (!bg_same) {
        if (size_x == 1 && size_y == 1) {
            drawFastVLine(x + 5, y, 8, bg);
        } else {
            fillRect(x + 5 * size_x, y, size_x, 8 * size_y, bg);
        }
    }
}

void Adafruit_GFX::setCursor(int16_t x, int16_t y) {
    cursor_x_ = x;
    cursor_y_ = y;
}

void Adafruit_GFX::setTextColor(uint16_t c) {
    textcolor_ = c;
    textbgcolor_ = c;
    text_bg_ = false;
}

void Adafruit_GFX::setTextColor(uint16_t c, uint16_t bg) {
    textcolor_ = c;
    textbgcolor_ = bg;
    text_bg_ = true;
}

void Adafruit_GFX::setTextSize(uint8_t s) {
    textsize_x_ = textsize_y_ = (s > 0) ? s : 1;
}

void Adafruit_GFX::setTextSize(uint8_t sx, uint8_t sy) {
    textsize_x_ = (sx > 0) ? sx : 1;
    textsize_y_ = (sy > 0) ? sy : 1;
}

void Adafruit_GFX::setTextWrap(bool w) {
    wrap_ = w;
}

void Adafruit_GFX::setRotation(uint8_t r) {
    rotation_ = r & 3;
    switch (rotation_) {
    case 0:
    case 2:
        width_ = WIDTH_;
        height_ = HEIGHT_;
        break;
    case 1:
    case 3:
        width_ = HEIGHT_;
        height_ = WIDTH_;
        break;
    }
}

size_t Adafruit_GFX::write(uint8_t c) {
    if (c == '\n') {
        cursor_x_ = 0;
        cursor_y_ += (int16_t)textsize_y_ * 8;
    } else if (c == '\r') {
        // ignore
    } else {
        if (wrap_ && ((cursor_x_ + (int16_t)textsize_x_ * 6) > width_)) {
            cursor_x_ = 0;
            cursor_y_ += (int16_t)textsize_y_ * 8;
        }
        drawChar(cursor_x_, cursor_y_, c, textcolor_, textbgcolor_, textsize_x_, textsize_y_);
        cursor_x_ += (int16_t)textsize_x_ * 6;
    }
    return 1;
}

int16_t Adafruit_GFX::width() const { return width_; }
int16_t Adafruit_GFX::height() const { return height_; }
uint8_t Adafruit_GFX::getRotation() const { return rotation_; }
int16_t Adafruit_GFX::getCursorX() const { return cursor_x_; }
int16_t Adafruit_GFX::getCursorY() const { return cursor_y_; }

const uint16_t* Adafruit_GFX::getFramebuffer() const { return framebuffer_; }
uint16_t* Adafruit_GFX::getFramebuffer() { return framebuffer_; }
